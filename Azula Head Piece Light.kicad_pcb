# Repository lendres/Azula-Head-Piece-Light

## KiCad design Azula Head Piece Light.kicad_pcb

Parts:
BT1: BK-883; BAT_BK-883; Manufacturer Part No. BK-883
D1, D2, D3: LED; LED_JB5630AWT-P-H40GA0000-NZ000001; Manufacturer Part No. JB5630AWT-P-H40GA0000-NZ000001
FID1, FID2, FID3: Fiducial; Fiducial_1mm_Mask2mm; Manufacturer Part No. None
L1: Logo; OSHW-Symbol_4mm_Silkscreen; Manufacturer Part No. None
R1, R2, R3: 200; 0805_2012Metric; Manufacturer Part No. RK73H2ATTD2000F
SW1: SW_DIP_x03; CL-SB-22A_HandSolder_Edge; Manufacturer Part No. CL-SB-22A-11T
TP1, TP2: TestPoint; Pad_2.5-2.5; Manufacturer Part No. None

Connections:
+3V0: R1.1, R2.1, R3.1, SW1.3, SW1.6, TP1.1
/BAT+: BT1.1 (VCC), SW1.2, SW1.5
GND: BT1.2 (GND), D1.1 (K(N)), D2.1 (K(N)), D3.1 (K(N)), TP2.1
unnamed: D1.2 (A(P)), R1.2
unnamed: D2.2 (A(P)), R2.2
unnamed: D3.2 (A(P)), R3.2

Notes on the sheet:
Additional Features
Schematic

Board: 2 copper layers, 35.8 x 18.0 mm, 14 parts (2 on the bottom side), 6 nets.

File Gerbers/Bill.of.Materials.xlsx:

Source: | S:\Projects and Builds\2020-10 Jenna's Costume\Electronics\Azula Head Piece Lig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
Date: | 44073.898240740738
Tool: | Eeschema (5.1.5)-3
Generator: | F:\Program Files\KiCad\bin\scripting\plugins/bom_csv_grouped_by_value.py
Component Count: | 9
Collated Components:
Item | Qty | Reference(s) | Value | LibPart | Footprint | Datasheet | Description | Manufacturer Name | Manufacturer Part No. | Source | Source Part No.
1 | 1 | BT1 | BK-883 | Power_LE:BK-883 | Azula Head Piece Light:BAT_BK-883 | https://www.memoryprotectiondevices.com/datasheets/BK-883-da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 | Battery Retainer Coin, 20.0mm 1 Cell SMD (SMT) Tab | MPD | BK-883 | Digikey | BK-883-ND
2 | 3 | D1, D2, D3 | LED | Frequently_Used_LE:LED | Azula Head Piece Light:LED_JB5630AWT-P-H40GA0000-NZ000001 | https://www.cree.com/led-components/media/documents/data-she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 | LED Lighting J White, Neutral 4000K 3-Step MacAdam Ellipse 2.71V 65mA 120Â° 221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 | Inolux | JB5630AWT-P-H40GA0000-NZ000001 | Digikey | 2138-JB5630AWT-P-H40GA0000-NZ000001CT-ND
3 | 1 | L1 | Logo | Frequently_Used_LE:Logo | Logos_LE:OSHW-Symbol_4mm_Silkscreen
4 | 3 | R1, R2, R3 | 200 | Frequently_Used_LE:R | FrequentlyUsed:0805_2012Metric | http://www.koaspeer.com/pdfs/RK73H.pdf | 200 Ohms Â±1% 0.25W, 1/4W Chip Resistor 0805 (2012 Metric) Automotive AEC-Q200,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 | KOA Speer Electronics, Inc. | RK73H2ATTD2000F | Digikey | 2019-RK73H2ATTD2000FCT-ND
5 | 1 | SW1 | SW_DIP_x03 | Azula Head Piece:SW_DIP_x03 | Azula Head Piece Light:CL-SB-22A_HandSolder_Edge | https://www.nidec-copal-electronics.com/e/catalog/switch/cl-sb.pdf | Slide Switch DPDT Surface Mount, Right Angle | Nidec Copal Electronics | CL-SB-22A-11T | Digikey | 563-1340-1-ND

## Commit log

2020-09-16 Fix LED orientation and switch wiring
    Fix LED orientation and switch wiring
    Version 1.0.1
2020-09-16 Fixed pin out on LED
    Fixed pin out on LED
2020-10-01 Added fiducials
